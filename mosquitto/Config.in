## mosquitto/Config.in
```kconfig
menu "Configuration"
    depends on PACKAGE_mosquitto

config MOSQUITTO_LWS
    bool "libwebsockets support"
    default y

endmenu
```
